# Keil uVision project Am32e230.uvprojx, settings and files
target GD32DEV_A_E230 (6160000::V6.16::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0001800) IROM(0x08000000,0x0008000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: AM32_GD32DEV_A_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, GD32DEV_A_E230
  c include: ..\mcu\e230\Drivers\CMSIS\Core\Include;..\mcu\e230\Drivers\GD32E23x_standard_peripheral\Include;..\mcu\e230\Drivers\CMSIS\Include;..\mcu\e230\Inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
  group Src
    ../Src/: dshot.c functions.c main.c signal.c sounds.c firmwareversion.c kiss_telemetry.c
  group cmis
    ../Mcu/e230/Drivers/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c
  group Startup
    ../Mcu/e230/Startup/mdk/: startup_gd32e23x.s
  group e230
    ../Mcu/e230/Src/: ADC.c comparator.c eeprom.c gd32e23x_it.c IO.c peripherals.c phaseouts.c serial_telemetry.c system_gd32e23x.c systick.c
target GD32DEV_B_E230 (6190000::V6.19::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: AM32_GD32DEV_B_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, GD32DEV_B_E230
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
target RHINO40A_E230 (6190000::V6.19::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: AM32_RHINO40A_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, RHINO40A_E230
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
target SKYSTARS_KM55_E230 (6210000::V6.21::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: AM32_SKYSTARS_KM55_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, SKYSTARS_KM55_E230
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
target SKYSTARS_AM60_E230 (6190000::V6.19::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: AM32_SKYSTARS_AM60_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, SKYSTARS_AM60_E230
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
target CM_MINI_E230 (6190000::V6.19::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: AM32_CM_MINI_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, CM_MINI_E230
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
target SKYSTARS_AM45_E230 (6190000::V6.19::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: AM32_SKYSTARS_AM45_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, SKYSTARS_AM45_E230
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
target SEQURE_TEST_E230 (6190000::V6.19::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: AM32_SEQURE_TEST_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, SEQURE_TEST_E230
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
target ARGUSFPV_R71_E230 (6160000::V6.16::ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: AM32_ARGUSFPV_R71_E230 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230, ARGUSFPV_R71_E230
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x7c00
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: ..\Mcu\e230\Am32.sct
software components: CMSIS:CORE 5.5.0
